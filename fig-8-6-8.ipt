# Autodesk Inventor part: sweep-path
## iProperties
Created: 2006-01
Part Number: sweep-path
Document SubType Name: Modeling
Designer: CADCIM
Density: 1 g/cm^3
Author: CADCIM
